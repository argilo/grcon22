options:
  parameters:
    author: argilo
    generate_options: no_gui
    id: sdrdle_tx
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '926000000'
  states: {}
- name: resamp_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: (samp_rate / 2)*0.48
    gain: '2.0'
    samp_rate: samp_rate
    width: (samp_rate / 2)*0.05
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: paint_image_source_0
  id: paint_image_source
  parameters:
    autocontrast: '0'
    bt709_map: '1'
    image_file: sdrdle.png
    image_flip: '1'
    image_invert: '0'
    repeatmode: '0'
  states: {}
- name: paint_paint_bc_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '8'
    width: '480'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: resamp_taps
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
    vga: '40'
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: '70'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [paint_image_source_0, '0', paint_paint_bc_0, '0']
- [paint_paint_bc_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', soapy_hackrf_sink_0, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
