options:
  parameters:
    category: RDS
    generate_options: hb
    id: rds_tx
    output_language: python
  states: {}

blocks:
- name: fm_max_dev
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 87.5e6
  states: {}
- name: rds_gain
  id: variable
  parameters:
    value: 5000 / fm_max_dev
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '380000'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.200'
    type: float
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: gr_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: gr_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: gr_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi*fm_max_dev/usrp_rate
  states: {}
- name: gr_map_bb_1
  id: digital_map_bb
  parameters:
    map: '[1,2]'
  states: {}
- name: gr_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: gr_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: gr_rds_encoder_0
  id: rds_encoder
  parameters:
    af1: 133.7e6
    ms: 'False'
    pi_country_code: '13'
    pi_coverage_area: '3'
    pi_reference_number: '147'
    ps: '"VE3IRR"'
    pty: '1'
    pty_locale: '1'
    radiotext: 'Signal identification challenge 4: flag{rad1O_d4ta_5yst3M}'
    ta: 'False'
    tp: 'True'
  states: {}
- name: gr_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 38e3
    offset: '0'
    phase: '0'
    samp_rate: usrp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: gr_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: rds_gain
    freq: 57e3
    offset: '0'
    phase: '0'
    samp_rate: usrp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: gr_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    freq: 19e3
    offset: '0'
    phase: '0'
    samp_rate: usrp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: gr_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: '1'
    interp: '1'
    samp_rate: usrp_rate
    type: interp_fir_filter_fff
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: '1'
    interp: '1'
    samp_rate: usrp_rate
    type: interp_fir_filter_fff
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: chan1
    type: float
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: chan2
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '380'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '380'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '38'
    interp: '96'
    taps: ''
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '160'
    gain: '111'
    interp: '160'
    ntaps: 160*11
    samp_rate: usrp_rate
    sym_rate: '2375'
    type: interp_fir_filter_fff
  states: {}

connections:
- [blocks_multiply_const_vxx_0_0, '0', gr_add_xx_1, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [gr_add_xx_1, '0', gr_frequency_modulator_fc_0, '0']
- [gr_diff_encoder_bb_0, '0', gr_map_bb_1, '0']
- [gr_frequency_modulator_fc_0, '0', rational_resampler_xxx_1, '0']
- [gr_map_bb_1, '0', gr_unpack_k_bits_bb_0, '0']
- [gr_multiply_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [gr_multiply_xx_1, '0', gr_add_xx_1, '2']
- [gr_rds_encoder_0, '0', gr_diff_encoder_bb_0, '0']
- [gr_sig_source_x_0, '0', gr_multiply_xx_1, '0']
- [gr_sig_source_x_0_0_0, '0', gr_multiply_xx_0, '0']
- [gr_sig_source_x_0_1, '0', gr_add_xx_1, '1']
- [gr_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [low_pass_filter_0_0, '0', gr_add_xx_1, '3']
- [low_pass_filter_0_0_0, '0', gr_multiply_xx_1, '1']
- [pad_source_0, '0', rational_resampler_xxx_0, '0']
- [pad_source_1, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_0_0, '0', low_pass_filter_0_0_0, '0']
- [rational_resampler_xxx_1, '0', pad_sink_0, '0']
- [root_raised_cosine_filter_0, '0', gr_multiply_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
