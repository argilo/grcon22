options:
  parameters:
    generate_options: no_gui
    id: pocsag
    output_language: python
    run_options: run
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: pocsag.dat
    type: byte
  states: {}
- name: mixalot_pocencode_0
  id: mixalot_pocencode
  parameters:
    baudrate: '1200'
    capcode: '123456'
    msg: 'Signal identification challenge #12: flag{b4cK_to_pag3_0n3}'
    symrate: '38400'
    type: '1'
  states: {}

connections:
- [mixalot_pocencode_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
