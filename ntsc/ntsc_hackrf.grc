options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: ntsc_hackrf
    output_language: python
    run_options: run
  states: {}

blocks:
- name: audio_filts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: audio_interp
  id: variable
  parameters:
    value: '32'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: samp_rate / audio_interp
  states: {}
- name: audio_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '12000'
    gain: audio_filts
    samp_rate: input_audio_rate * audio_filts
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 438000000+1250000
  states: {}
- name: digital_gain
  id: variable
  parameters:
    value: '0.88'
  states: {}
- name: horizontal_rate
  id: variable
  parameters:
    value: 60 * .999 * 525 / 2
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '45'
  states: {}
- name: input_audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samples_per_line * horizontal_rate
  states: {}
- name: samples_per_line
  id: variable
  parameters:
    value: '768'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '0.6'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samples_per_line // audio_interp
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_3
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '2'
    offset: '0'
    phase: '0'
    samp_rate: samples_per_line // audio_interp
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 2475000 + 1725000
    low_cutoff_freq: '-2475000 + 1725000'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '500000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: 5 * horizontal_rate
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 6.5 * horizontal_rate
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out.c32
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: baseband.dat
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: digital_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '5000'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '5000'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * math.pi * 4500000 / samp_rate
  states: {}
- name: blocks_rotator_cc_1
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * math.pi * -1750000 / samp_rate
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '0.5'
    samp_rate: audio_rate
    sensitivity: 2 * math.pi
  states: {}
- name: blocks_vco_f_0_0
  id: blocks_vco_f
  parameters:
    amplitude: '0.5'
    samp_rate: audio_rate
    sensitivity: 2 * math.pi
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: part1.wav
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: part3.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: part4.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_1_0
  id: blocks_wavfile_source
  parameters:
    file: part5.wav
    repeat: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    note: L+R
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: L-R
  states: {}
- name: note_1
  id: note
  parameters:
    note: SAP
  states: {}
- name: note_2
  id: note
  parameters:
    note: PRO
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '0'
    freq0: center_freq
    gain0: '0'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: audio_filts
    rrate: audio_rate / input_audio_rate
    taps: audio_taps
    type: fff
  states: {}
- name: pfb_arb_resampler_xxx_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: audio_filts
    rrate: audio_rate / input_audio_rate
    taps: audio_taps
    type: fff
  states: {}
- name: pfb_arb_resampler_xxx_0_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: audio_filts
    rrate: audio_rate / input_audio_rate
    taps: audio_taps
    type: fff
  states: {}
- name: pfb_arb_resampler_xxx_0_1
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: audio_filts
    rrate: audio_rate / input_audio_rate
    taps: audio_taps
    type: fff
  states: {}
- name: pfb_arb_resampler_xxx_1
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 8000000 / samp_rate
    type: ccf
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: audio_interp
    type: ccc
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_1, '1']
- [analog_sig_source_x_3, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', blocks_add_xx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_vco_f_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_vco_f_0_0, '0']
- [blocks_add_xx_0, '0', blocks_rotator_cc_1, '0']
- [blocks_add_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_add_xx_1, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_rotator_cc_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_1, '2']
- [blocks_rotator_cc_0, '0', blocks_add_xx_0, '1']
- [blocks_rotator_cc_1, '0', pfb_arb_resampler_xxx_1, '0']
- [blocks_vco_f_0, '0', blocks_add_xx_1, '3']
- [blocks_vco_f_0_0, '0', blocks_add_xx_1, '4']
- [blocks_wavfile_source_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_wavfile_source_0_0, '0', pfb_arb_resampler_xxx_0_1, '0']
- [blocks_wavfile_source_1, '0', pfb_arb_resampler_xxx_0_0, '0']
- [blocks_wavfile_source_1_0, '0', pfb_arb_resampler_xxx_0_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_add_xx_1, '0']
- [pfb_arb_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_2, '0']
- [pfb_arb_resampler_xxx_0_0_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [pfb_arb_resampler_xxx_0_1, '0', blocks_multiply_xx_0, '0']
- [pfb_arb_resampler_xxx_1, '0', blocks_file_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0-rc1
