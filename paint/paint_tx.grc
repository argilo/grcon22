options:
  parameters:
    generate_options: no_gui
    id: paint_tx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '923500000'
  states: {}
- name: data
  id: variable
  parameters:
    value: (0,)*4096
  states: {}
- name: noise_amp
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: resamp_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate * 0.48
    gain: '8'
    samp_rate: samp_rate * 8
    width: samp_rate * 0.05
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: signal_to_noise.sigmf-data
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: data
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: rate
    type: ccf
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '7'
    interp: '8'
    taps: resamp_taps
    type: ccc
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_source_x_0, '0', rational_resampler_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_add_xx_0, '0']
- [rational_resampler_xxx_0, '0', pfb_arb_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0-rc1
