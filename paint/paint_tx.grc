options:
  parameters:
    generate_options: no_gui
    id: paint_tx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '923500000'
  states: {}
- name: data
  id: variable
  parameters:
    value: (0,)*4096
  states: {}
- name: rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: resamp_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: (samp_rate / 2)*0.48
    gain: '2.0'
    samp_rate: samp_rate
    width: (samp_rate / 2)*0.05
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: final.c32
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: data
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: rate
    type: ccf
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: resamp_taps
    type: ccc
  states: {}

connections:
- [blocks_vector_source_x_0, '0', rational_resampler_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_file_sink_0, '0']
- [rational_resampler_xxx_0, '0', pfb_arb_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-181-g643e1337
