options:
  parameters:
    generate_options: no_gui
    id: paint1
    output_language: python
    run_options: run
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '923500000'
  states: {state: disabled}
- name: rate
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '0.1'
    stop: '200'
    value: '100'
  states: {state: disabled}
- name: resamp_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: (samp_rate / 2)*0.48
    gain: '2.0'
    samp_rate: samp_rate
    width: (samp_rate / 2)*0.05
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: rect.c32
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/argilo/Documents/bso2019/hop/flags.c32
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: complex
  states: {state: disabled}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * math.pi * -1000000 / samp_rate
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {state: disabled}
- name: paint_image_source_0
  id: paint_image_source
  parameters:
    autocontrast: '0'
    bt709_map: '1'
    image_file: logo-flag.png
    image_flip: '1'
    image_invert: '0'
    repeatmode: '0'
  states: {}
- name: paint_paint_bc_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '1'
    width: '449'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: rate
    type: ccf
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    tr_level: '0.9'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '-20'
    int_min: '-100'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: resamp_taps
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_args: '"send_frame_size=65536,num_send_frames=128"'
    gain0: '89'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_add_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_rotator_cc_0_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [paint_image_source_0, '0', paint_paint_bc_0, '0']
- [paint_paint_bc_0, '0', blocks_file_sink_0, '0']
- [paint_paint_bc_0, '0', rational_resampler_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_rotator_cc_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-181-g643e1337
